# Keil uVision project Gps_Tracking_System.uvproj, settings and files
target Gps_Tracking_System (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Gps_Tracking_System
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;Includes
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c
    ./lcd/: LCD.c
    ./PLL/: PLL.c
    ./PortF/: portF.c
    ./Systick/: systick.c
    ./UART/: UART.c
    ./DistanceCalculation/: DistanceCalculation.c
    ./StringManipulation/: ExtractString.c getCoordinates.c esp.c
  group Includes
    ./: tm4c123gh6pm.h Types.h
    ./lcd/: LCD.h
    ./PLL/: PLL.h
    ./PortF/: portF.h
    ./Systick/: systick.h
    ./UART/: UART.h
    ./DistanceCalculation/: DistanceCalculation.h
    ./StringManipulation/: ExtractString.h getCoordinates.h esp.h
